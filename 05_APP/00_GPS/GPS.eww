<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\01_MCAL\01_GPIO\GPIO.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\GPS.ewp</path>
  </project>
  <batchBuild/>
</workspace>


