# IAR project RTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GE6PM TexasInstruments TM4C123GE6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: RTOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group lib
    ./: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_prototypes.h mpu_wrappers.h portable.h portasm.s portmacro.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h TM4C123GH6PM.h uart.h
  group src
    ./: cstartup_M.c heap_2.c list.c port.c queue.c tasks.c uart.c
